IMAGE_INSTALL:append = " screen"
IMAGE_INSTALL:append = " watchdogtimer"
IMAGE_INSTALL:append = " jetsonenable"
IMAGE_INSTALL:append = " perifenable"
IMAGE_INSTALL:append = " packagegroup-meta-scales-leviathan-python"
IMAGE_INSTALL:append = " python-monitors"


